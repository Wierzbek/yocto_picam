


DESCRIPTION:append = "test image"

#require recipes-core/images/core-image-base.bb

IMAGE_INSTALL:append += " picam"
